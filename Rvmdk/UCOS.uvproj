# Keil uVision project UCOS.uvproj, settings and files
target STM32F105RC (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Y06 +hex
  AfterMake: fromelf.exe --bin -o  ..\Obj\Bin\Y06-APP.bin  ..\List\Y06.axf
  c flags: Optim=3 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, DEF_OBDTASK_CREATE ,WJH_TEST
  c include: ..\src\COM_ISR;..\src\COM_STM32Lib;..\src\COM_UCOSII;..\src\DEV_SRC\DEV_BSP;..\src\DEV_SRC\DEV_APP;..\src\DEV_SRC\DEV_DOC;..\src\DEV_SRC\DEV_MAIN;..\src\DEV_SRC\DEV_PROTOCOLLib
  library: MicroLIB
  memory RVCT4: ROM 0x800a000 size 0x26000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group DEV_CGF
    ../src/DEV_SRC/DEV_MAIN/: cfg_h.h main_h.h
    ../src/DEV_SRC/DEV_APP/: hal_h.h hal_protocol_h.h
  group DEV_MAIN
    ../src/DEV_SRC/DEV_MAIN/: main_c.c
  group DEV_APP
    ../src/DEV_SRC/DEV_APP/: hal_c.c hal_protocol_c.c hal_processQUE_c.c hal_processSYS_c.c hal_processGPS_c.c hal_processDBG_c.c hal_processOBD_c.c hal_processACC_c.c hal_processCON_c.c
  group DEV_BSP
    ../src/DEV_SRC/DEV_BSP/: bsp_c.c bsp_rtc_c.c bsp_gsm_c.c bsp_acc_c.c bsp_can_c.c bsp_storage_c.c bsp_kline_c.c bsp_gps_c.c des_c.c
  group DEV_Doc
    ../src/DEV_SRC/DEV_DOC/: doc.txt
  group COM_ISR
    ../src/COM_ISR/: stm32f10x_it.c
  group COM_FWLib
    ../src/COM_STM32Lib/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
  group COM_UCOSII
    ../src/COM_UCOSII/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group COM_OS_PORT
    ../src/COM_UCOSII/: ucos_ii.h os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group COM_StartUp
    ../src/COM_STM32Lib/StartUp/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
  group OBD_NON_STANDARD_CMD
    ../src/OBD_LIB/OBD_NON STANDARD/Command/Source/: zxt_obd_all_car_cfg.c zxt_obd_all_sys_cfg.c
  group OBD_NON_STANDARD_FUN
    ../src/OBD_LIB/OBD_NON STANDARD/Funlib/Source/: zxt_obd_fun_lib_cfg.c zxt_obd_fun_lib_Variable_init.c
  group OBD_NON_STANDARD_PROTOCOL
    ../src/OBD_LIB/OBD_NON STANDARD/Protocol/Source/: zxt_obd_protocol_cfg.c
  group OBD_PUBLIC_DRIVER
    ../src/OBD_LIB/OBD_PUBLIC/Driver/Source/: zxt_obd_app_variables_init.c Zxt_obd_bsp.c
  group OBD_PUBLIC_TASK
    ../src/OBD_LIB/OBD_PUBLIC/Task/Source/: zxt_obd_interrupt_process.c zxt_obd_task_create.c zxt_obd_task_ecu_process.c zxt_obd_task_fun_process.c zxt_obd_task_schedule.c zxt_obd_task_variables.c zxt_obd_transferlayer_process.c
  group OBD_STANDARD_CMD
    ../src/OBD_LIB/OBD_STANDARD/Command/Source/: zxt_obd_std_cmd.c zxt_obd_std_obd_cfg.c
  group OBD_STANDARD_FUN
    ../src/OBD_LIB/OBD_STANDARD/Funlib/Source/: zxt_obd_clear_dtc.c zxt_obd_create_link.c zxt_obd_data_stream.c zxt_obd_get_odometer.c zxt_obd_read_dtc.c zxt_obd_sys_exit.c zxt_obd_getvin.c
    ../src/OBD_LIB/OBD_COMM_LIB/: OBDLIB.lib
target STM32F105RC-DEV (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: as above
  output: Y06 +hex
  AfterMake: C:\Keil474\ARM\BIN31\fromelf.exe --bin -o  ..\Obj\Bin\Y06.bin  ..\List\Y06.axf
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x800a000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
